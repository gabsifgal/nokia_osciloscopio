# Keil uVision project Osciloscopio.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Osciloscopio
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Nokia5110.c Nokia5110.h startup.s tm4c123gh6pm.h main.c Terminal3.h Terminal6.h Terminal12.h TivaES.h TivaES.obj osciloscopio.h moduloADC.c moduloADC.h ElementosGraficos.h Uart.h Uart.c PuertosDFyTimer.h PuertosDFyTimer.c
    ../: bitmap.h
